# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\POS_MACH;..\HARDWARE\PWM;..\HARDWARE\LED;..\HARDWARE\CTRL;..\HARDWARE\PID;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\STEPMOTOR;..\HARDWARE\IIC;..\HARDWARE\CSB;..\HARDWARE\FILTER;..\HARDWARE\UART3;..\HARDWARE\CSB-KS103;..\HARDWARE\UART2;..\HARDWARE\FILTER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../HARDWARE/PWM/: pwm_out.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/POS_MACH/: pos_mach.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CTRL/: ctrl.c
    ../HARDWARE/PID/: pid.c FUZZY_PID.C
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/UART3/: UART3.c
    ../HARDWARE/UART2/: UART2.c
    ../HARDWARE/FILTER/: FILTER.C
